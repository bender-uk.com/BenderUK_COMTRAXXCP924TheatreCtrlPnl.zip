Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-10-23T12:30:46
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcBuildingElementProxy: NBS_BenderUK_OperatingTheatreControlPanels_COMTRAXXCP924TheatreControlPanel:COMTRAXXCP924TheatreControlPanel, NBS_BenderUK_OperatingTheatreControlPanels_COMTRAXXCP924TheatreControlPanel:COMTRAXXCP924TheatreControlPanel:320771
In: Level 0
Type - Classification: Pr_75_50_18_58 (Uniclass2015); Material: NBS_BenderUK_Grey (6), NBS_BenderUK_DisplayScreen, NBS_BenderUK_White
Type - IFC - IfcExportAs: IfcUnitaryControlElementType; IfcExportType: CONTROLPANEL
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_75_50_18_58:Operating theatre control panels; Color: n/a; Finish: n/a; Material: Glass; Shape: Rectangle; Size: n/a; WarrantyDescription: Two year; CodePerformance: n/a; Constituents: n/a; Description: Glass touch alarm indicator and operator panel for medical locations.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: marketing@bender-uk.com; ModelNumber: n/a; ModelReference: COMTRAXX® CP9 24” Theatre Control Panel; Name: OperatingTheatreControlPanels_COMTRAXXCP924TheatreControlPanel_BenderUK; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_BenderUK_OperatingTheatreControlPanels_COMTRAXXCP924TheatreControlPanel; ManufacturerName: Bender UK; ManufacturerURL: www.bender-uk.com; ProductInformation: https://source.thenbs.com/product/-/2a742456-b47a-49e3-80e6-03ad0a317d62/04d638c9-f6c3-46bd-a207-2ff0ea018029; Uniclass2015Code: Pr_75_50_18_58; Uniclass2015Title: Operating theatre control panels; Uniclass2015Version: Products v1.35; Version: 6
Type - NBS_Data - Standards: To HTM 03-01; Certification: CE certified; Accessories: None,CP9xx replacement plug connector kit - B95061910,CP9xx suction lifter - B95061911; CountryOfProductManufacture: Germany; Material: Glass; ManufacturingPlantLocation: Londorfer Str. 65, 35305 Grünberg, Germany; Recyclability: Product can be returned to manufacturer for recycling in line with WEEE regulations; IngressProtectionIPRating: IP54; PowerSupply: 100–240 V a.c.,<55 W; Controller: PLC (Programmable Logic Controller) Interface box; Input: 40 digital inputs, 4 analogue inputs; Output: 16 digital outputs, 4 analogue outputs; IntegralAccessories: Flush-mounting enclosure including mounting plate with electronics, CP9xx connecting cable and plug connector kit
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
